# Keil uVision project probe_ulinkpro_revAA.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F205VF STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80BFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: probe_ulinkpro_revAA
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
